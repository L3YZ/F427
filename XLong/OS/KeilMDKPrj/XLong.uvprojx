# Keil uVision project XLong.uvprojx, settings and files
target FLASH (ARM-ADS)
  device: STM32F427VI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: XLong +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER
  c include: ..\..\..\CMSIS\4.5.0\CMSIS\Include;..\APP;..\APP\ST;..\APP\uCOS;..\..\BSP\KeilMDK;..\..\BSP\Board\inc;..\..\BSP\STM32F4xx\inc;..\..\BSP\Xlong\inc;..\..\..\uCOS\uC-CPU;..\..\..\uCOS\uC-CPU\Ports\ARM-Cortex-M4;..\..\..\uCOS\uC-LIB;..\..\..\uCOS\uC-LIB\Ports\ARM-Cortex-M4;..\..\..\uCOS\uCOS-III\Source;..\..\..\uCOS\uCOS-III\Ports\ARM-Cortex-M4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../APP/: app.c includes.h
  group APP_ST
    ../APP/ST/: stm32f4xx.h stm32f4xx_conf.h
  group APP_uCOS_Config
    ../APP/uCOS/: app_cfg.h cpu_cfg.h lib_cfg.h os_cfg.h os_cfg_app.h os_app_hooks.h os_app_hooks.c
  group BSP_XLong
    ../../BSP/XLong/src/: PWM.c
  group BSP_uCOS
    ../../BSP/Board/inc/: bsp.h
    ../../BSP/Board/src/: bsp.c bsp_int.c bsp_periph.c
  group BSP_KeilMDK
    ../../BSP/KeilMDK/: cstartup.s
  group BSP_STM32F4xx Library
    ../../BSP/STM32F4xx/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group uC-CPU
    ../../../uCOS/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC-CPU/Ports/CortexM4
    ../../../uCOS/uC-CPU/Ports/ARM-Cortex-M4/: cpu_c.c cpu.h cpu_a.asm
  group uC-LIB
    ../../../uCOS/uC-LIB/: lib_def.h lib_ascii.c lib_ascii.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC-LIB/Ports/CortexM4
    ../../../uCOS/uC-LIB/Ports/ARM-Cortex-M4/: lib_mem_a.asm
  group uCOS-III/Source
    ../../../uCOS/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uCOS-III/Ports/CortexM4
    ../../../uCOS/uCOS-III/Ports/ARM-Cortex-M4/: os_cpu.h os_cpu_a.asm os_cpu_c.c
target SRAM (ARM-ADS)
  device: STM32F427VI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: as above
  output: XLong +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\APP;..\APP\ST;..\APP\uCOS;..\..\BSP\KeilMDK;..\..\BSP\Board\inc;..\..\BSP\STM32F4xx\inc;..\..\..\uCOS\uC-CPU;..\..\..\uCOS\uC-CPU\Ports\ARM-Cortex-M4;..\..\..\uCOS\uC-LIB;..\..\..\uCOS\uC-LIB\Ports\ARM-Cortex-M4;..\..\..\uCOS\uCOS-III\Source;..\..\..\uCOS\uCOS-III\Ports\ARM-Cortex-M4;..\..\..\CMSIS\\4.5.0\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
